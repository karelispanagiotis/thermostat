# Keil uVision project Thermostat.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Thermostat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src;.\drivers
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group src
    ./src/: main.c onewire.c onewire.h proximity.c proximity.h thermometer.c thermometer.h delay.c delay.h lcd.c lcd.h leds.c leds.h
  group drivers
    ./drivers/: platform.h gpio.c gpio.h timer.c timer.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
